<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dp</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_3</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_4</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_5</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>dab_fib_source_b</key>
<param><key>id</key><value>dab_fib_source_b_0</value></param>
<param><key>data_rate_n</key><value>15</value></param>
<param><key>ensemble_label</key><value>"Galaxy News"</value></param>
<param><key>num_subch</key><value>7</value></param>
<param><key>protection_mode</key><value>3</value></param>
<param><key>service_comp_label</key><value>"Music mix 1"</value></param>
<param><key>service_comp_lang</key><value>1</value></param>
<param><key>programme_service_label</key><value>"Galaxy News Radio"</value></param>
<param><key>transmission_mode</key><value>1</value></param>
</block>
<block>
<key>dab_fic_encode</key>
<param><key>id</key><value>dab_fic_encode_0</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_msc_encode</key>
<param><key>id</key><value>dab_msc_encode_0</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>data_rate_n</key><value>15</value></param>
<param><key>protection</key><value>3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_msc_encode</key>
<param><key>id</key><value>dab_msc_encode_0_0</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>data_rate_n</key><value>15</value></param>
<param><key>protection</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_msc_encode</key>
<param><key>id</key><value>dab_msc_encode_0_1</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>data_rate_n</key><value>9</value></param>
<param><key>protection</key><value>3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_msc_encode</key>
<param><key>id</key><value>dab_msc_encode_0_2</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>data_rate_n</key><value>3</value></param>
<param><key>protection</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_msc_encode</key>
<param><key>id</key><value>dab_msc_encode_0_3</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>data_rate_n</key><value>15</value></param>
<param><key>protection</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_msc_encode</key>
<param><key>id</key><value>dab_msc_encode_0_4</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>data_rate_n</key><value>0</value></param>
<param><key>protection</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_msc_encode</key>
<param><key>id</key><value>dab_msc_encode_0_5</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>data_rate_n</key><value>9</value></param>
<param><key>protection</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_ofdm_mod</key>
<param><key>id</key><value>dab_ofdm_mod_0</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_transmission_frame_mux_bb</key>
<param><key>id</key><value>dab_transmission_frame_mux_bb_0</value></param>
<param><key>subch_size</key><value>[15, 15, 15, 9, 9, 3, 0]</value></param>
<param><key>transmission_mode</key><value>dp</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>227.36e6</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>36</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>2e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>dab_msc_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_0</source_block_id><sink_block_id>dab_msc_encode_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_1</source_block_id><sink_block_id>dab_msc_encode_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_2</source_block_id><sink_block_id>dab_msc_encode_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_3</source_block_id><sink_block_id>dab_msc_encode_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_4</source_block_id><sink_block_id>dab_msc_encode_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_5</source_block_id><sink_block_id>dab_msc_encode_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_fib_source_b_0</source_block_id><sink_block_id>dab_fic_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_fic_encode_0</source_block_id><sink_block_id>dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_msc_encode_0</source_block_id><sink_block_id>dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dab_msc_encode_0_0</source_block_id><sink_block_id>dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>dab_msc_encode_0_1</source_block_id><sink_block_id>dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>dab_msc_encode_0_2</source_block_id><sink_block_id>dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>dab_msc_encode_0_3</source_block_id><sink_block_id>dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>dab_msc_encode_0_4</source_block_id><sink_block_id>dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>dab_msc_encode_0_5</source_block_id><sink_block_id>dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>dab_ofdm_mod_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_transmission_frame_mux_bb_0</source_block_id><sink_block_id>dab_ofdm_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_transmission_frame_mux_bb_0</source_block_id><sink_block_id>dab_ofdm_mod_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
