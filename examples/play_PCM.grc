<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/luca/Documents/CEL/DAB/gr-dab/python/debug/PCM_left2.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/luca/Documents/CEL/DAB/gr-dab/python/debug/PCM_right2.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
