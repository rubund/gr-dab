<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>220352000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_slider</value></param>
<param><key>value</key><value>26</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1.0/256</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1.0/256</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>2492*8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>2492*8</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0</value></param>
<param><key>delay</key><value>4000</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1536</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_3</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_4</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>64</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1536</value></param>
</block>
<block>
<key>capture_tools_threshold_tag_other_stream_cc</key>
<param><key>id</key><value>capture_tools_threshold_tag_other_stream_cc_0</value></param>
<param><key>going_high_tag</key><value>"going_high"</value></param>
<param><key>going_low_tag</key><value>"hererjeg"</value></param>
<param><key>high_thresh</key><value>0.6</value></param>
<param><key>low_thresh</key><value>0.5</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>capture_tools_threshold_tag_other_stream_cc</key>
<param><key>id</key><value>capture_tools_threshold_tag_other_stream_cc_0_0</value></param>
<param><key>going_high_tag</key><value>"first"</value></param>
<param><key>going_low_tag</key><value>"going_low"</value></param>
<param><key>high_thresh</key><value>0.6</value></param>
<param><key>low_thresh</key><value>0.5</value></param>
<param><key>vlen</key><value>1536</value></param>
</block>
<block>
<key>dab_complex_to_interleaved_float_vcf</key>
<param><key>id</key><value>dab_complex_to_interleaved_float_vcf_0</value></param>
<param><key>length</key><value>1536</value></param>
</block>
<block>
<key>dab_dabplus_audio_decoder_ff</key>
<param><key>id</key><value>dab_dabplus_audio_decoder_ff_0</value></param>
<param><key>address</key><value>192</value></param>
<param><key>bit_rate</key><value>112</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>output_float</key><value>True</value></param>
<param><key>protection</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>subch_size</key><value>112</value></param>
</block>
<block>
<key>dab_detect_null</key>
<param><key>id</key><value>dab_detect_null_0</value></param>
<param><key>length</key><value>2594</value></param>
</block>
<block>
<key>dab_diff_phasor_vcc</key>
<param><key>id</key><value>dab_diff_phasor_vcc_0_0</value></param>
<param><key>num_carriers</key><value>1536</value></param>
</block>
<block>
<key>dab_frequency_interleaver_vcc</key>
<param><key>id</key><value>dab_frequency_interleaver_vcc_0</value></param>
<param><key>interleaving_sequence</key><value>[972, 1260, 1417, 367, 1370, 1214, 1024, 95, 568, 1116, 184, 572, 85, 978, 475, 202, 1503, 790, 319, 577, 170, 548, 1274, 106, 725, 254, 247, 383, 51, 1462, 339, 1378, 1282, 1088, 1525, 4, 1297, 656, 764, 906, 94, 169, 1087, 983, 803, 1195, 984, 225, 276, 613, 437, 205, 92, 1523, 1014, 918, 257, 865, 1146, 804, 766, 131, 849, 1404, 45, 920, 101, 1193, 1230, 87, 495, 148, 1196, 783, 430, 1388, 1488, 1410, 1478, 252, 593, 445, 563, 1394, 25, 985, 749, 160, 1347, 1459, 499, 1212, 1455, 356, 1352, 1425, 362, 754, 226, 832, 1153, 1091, 219, 953, 737, 1379, 1326, 249, 653, 71, 448, 277, 910, 272, 681, 1034, 1494, 419, 479, 967, 896, 531, 1385, 63, 614, 578, 316, 1449, 679, 581, 352, 467, 1082, 538, 1496, 196, 269, 438, 674, 665, 1350, 294, 957, 304, 1226, 96, 809, 671, 1428, 1415, 206, 208, 428, 1128, 739, 486, 1314, 798, 827, 1469, 1001, 405, 478, 93, 1013, 1511, 1243, 1006, 1360, 1046, 18, 1077, 514, 523, 1457, 330, 1524, 1476, 924, 308, 1357, 862, 1484, 1016, 1507, 180, 74, 900, 474, 1015, 1329, 1492, 1306, 235, 595, 1286, 937, 971, 977, 246, 905, 91, 919, 1477, 1211, 736, 418, 351, 303, 1313, 1045, 1483, 1285, 302, 1232, 258, 1061, 795, 980, 1303, 1175, 1233, 287, 1512, 66, 61, 719, 926, 866, 406, 708, 1051, 442, 705, 259, 348, 359, 951, 933, 376, 618, 1147, 1166, 1130, 1217, 1293, 965, 1062, 599, 1392, 323, 164, 325, 1441, 805, 0, 385, 1445, 843, 566, 796, 1402, 440, 296, 1517, 1308, 1159, 767, 1064, 1170, 1435, 398, 935, 981, 1283, 774, 1141, 744, 696, 311, 132, 452, 1222, 583, 1028, 104, 1304, 22, 702, 1277, 961, 192, 721, 850, 171, 1099, 1074, 365, 512, 1176, 210, 1382, 395, 421, 1251, 813, 1405, 400, 1071, 177, 426, 1109, 1234, 1058, 569, 998, 175, 333, 262, 46, 1020, 1111, 1081, 1381, 646, 288, 1452, 346, 611, 975, 1399, 34, 921, 49, 909, 451, 11, 638, 1513, 38, 1003, 1178, 158, 358, 777, 102, 1454, 1401, 887, 554, 781, 67, 1330, 942, 1203, 1023, 576, 1281, 1194, 1145, 147, 24, 753, 447, 62, 268, 1414, 477, 329, 473, 90, 1231, 925, 617, 1440, 1158, 310, 720, 812, 261, 33, 776, 1280, 89, 88, 778, 1320, 659, 507, 730, 927, 391, 1244, 632, 83, 860, 779, 496, 373, 504, 642, 298, 215, 867, 854, 52, 1183, 403, 1397, 1321, 149, 676, 741, 992, 237, 112, 407, 601, 1437, 292, 424, 166, 660, 1197, 787, 1240, 995, 1267, 1465, 709, 888, 529, 959, 121, 341, 508, 784, 1055, 915, 1208, 940, 378, 1052, 1089, 1433, 1206, 757, 140, 731, 431, 12, 1472, 354, 1164, 389, 443, 321, 290, 335, 123, 626, 928, 1389, 549, 1270, 1500, 465, 129, 706, 502, 647, 458, 481, 989, 392, 1489, 592, 1421, 1262, 168, 1044, 260, 127, 1117, 280, 604, 117, 1245, 1411, 902, 1236, 547, 1328, 1144, 349, 574, 35, 1337, 587, 1323, 633, 1479, 380, 1259, 17, 37, 1290, 360, 1291, 81, 212, 189, 1354, 84, 253, 763, 204, 44, 1409, 498, 952, 1493, 580, 956, 485, 1359, 861, 594, 350, 1174, 704, 964, 565, 934, 103, 511, 1108, 645, 637, 780, 446, 309, 729, 214, 111, 1464, 377, 388, 128, 1043, 1143, 1289, 497, 564, 1463, 1364, 1187, 28, 1365, 619, 667, 1007, 830, 597, 493, 374, 1395, 1299, 649, 1254, 1519, 1188, 1148, 534, 1237, 240, 435, 1301, 505, 26, 55, 488, 881, 543, 29, 1167, 825, 223, 337, 244, 327, 643, 986, 837, 946, 229, 410, 1366, 1131, 555, 182, 306, 885, 42, 299, 750, 186, 264, 759, 1135, 620, 1218, 1526, 1467, 609, 1335, 1119, 216, 161, 639, 1040, 469, 840, 668, 1294, 663, 1069, 1419, 343, 817, 868, 1348, 1275, 913, 222, 462, 1008, 966, 701, 289, 1068, 969, 747, 855, 1460, 922, 345, 591, 662, 831, 1063, 1054, 185, 685, 1339, 693, 53, 500, 1192, 1060, 267, 251, 598, 600, 824, 1504, 1121, 873, 151, 1184, 1213, 318, 1377, 802, 864, 494, 1393, 361, 70, 1384, 195, 1427, 404, 1456, 899, 904, 301, 718, 375, 324, 1307, 695, 191, 1250, 332, 1398, 357, 575, 472, 1279, 859, 1396, 165, 340, 139, 625, 988, 116, 1322, 1353, 1358, 636, 1288, 492, 1300, 326, 41, 1118, 816, 746, 692, 150, 1426, 331, 115, 691, 57, 650, 1442, 1180, 1361, 137, 8, 58, 677, 363, 463, 460, 1104, 1310, 1255, 806, 1096, 1431, 835, 1094, 651, 742, 755, 1333, 1316, 771, 1010, 1520, 1, 1505, 47, 125, 1345, 1443, 993, 227, 711, 558, 713, 282, 1189, 386, 285, 1228, 949, 1181, 238, 833, 686, 369, 142, 1531, 1149, 1446, 5, 274, 793, 1318, 1362, 113, 1154, 1514, 1125, 1084, 699, 535, 844, 50, 970, 1413, 510, 138, 408, 1092, 107, 1342, 589, 1106, 1238, 567, 1475, 1453, 762, 898, 9, 602, 220, 791, 819, 77, 1199, 241, 797, 1451, 573, 823, 1486, 59, 1438, 954, 1375, 571, 724, 655, 436, 1403, 1487, 1458, 218, 1033, 678, 293, 738, 1005, 1356, 234, 417, 1302, 441, 1292, 842, 397, 1027, 364, 425, 1380, 10, 553, 752, 1157, 506, 297, 236, 1266, 939, 1163, 464, 167, 1327, 36, 1408, 963, 110, 27, 1518, 542, 409, 1134, 839, 461, 661, 250, 863, 717, 858, 491, 56, 1309, 1009, 281, 1530, 698, 1105, 1198, 654, 416, 1156, 109, 490, 489, 1160, 154, 1047, 893, 1113, 1311, 788, 72, 1021, 483, 1248, 1161, 882, 768, 890, 1030, 688, 606, 1256, 1241, 449, 15, 800, 232, 155, 544, 1065, 1122, 1371, 628, 518, 807, 996, 278, 683, 821, 560, 1048, 30, 1171, 68, 1373, 98, 314, 1097, 1268, 911, 1340, 525, 733, 894, 1168, 1436, 1298, 40, 1325, 773, 1432, 1466, 273, 39, 1138, 540, 1114, 826, 399, 320, 748, 1535, 786, 836, 710, 682, 726, 527, 1018, 1312, 224, 936, 100, 347, 853, 533, 1095, 889, 1035, 845, 870, 1369, 789, 338, 982, 256, 86, 562, 1424, 652, 530, 1495, 670, 1000, 522, 73, 245, 1284, 60, 932, 163, 1516, 743, 960, 420, 174, 974, 157, 1022, 328, 775, 82, 402, 423, 120, 756, 122, 480, 603, 586, 188, 484, 644, 1142, 596, 434, 243, 884, 1334, 342, 968, 1338, 872, 194, 1249, 987, 745, 7, 1093, 1344, 948, 1317, 509, 897, 1485, 1032, 1026, 1162, 838, 697, 1112, 605, 517, 313, 772, 785, 532, 1423, 1515, 119, 883, 947, 312, 199, 19, 413, 200, 1011, 1056, 1386, 1215, 990, 879, 769, 230, 133, 1036, 78, 371, 20, 1521, 916, 64, 630, 828, 135, 891, 411, 453, 874, 1263, 930, 414, 2, 1209, 615, 727, 634, 715, 1031, 1367, 1223, 1331, 622, 811, 201, 1506, 941, 579, 694, 1265, 433, 689, 1132, 584, 657, 1139, 1509, 1012, 48, 379, 317, 1004, 173, 1498, 607, 556, 1029, 1422, 856, 1225, 1057, 126, 1053, 1450, 255, 734, 1201, 1257, 183, 105, 1296, 612, 848, 1387, 1346, 1090, 680, 1448, 1349, 1127, 1242, 307, 1305, 735, 979, 1050, 1216, 1444, 1434, 582, 1073, 176, 1080, 450, 886, 23, 1439, 658, 641, 991, 994, 1207, 353, 1499, 1261, 546, 16, 43, 703, 213, 1186, 1253, 880, 228, 758, 468, 221, 590, 266, 801, 300, 1278, 1287, 690, 1103, 770, 712, 141, 1083, 588, 76, 723, 233, 751, 962, 857, 108, 1247, 231, 559, 732, 539, 1017, 1368, 521, 156, 187, 193, 1025, 118, 878, 134, 714, 432, 1497, 1200, 1126, 1079, 545, 265, 722, 520, 1078, 455, 1037, 283, 13, 197, 536, 393, 456, 1066, 760, 851, 846, 1480, 144, 79, 1190, 1473, 270, 1220, 1470, 1038, 1123, 1136, 172, 152, 1151, 1391, 372, 387, 355, 439, 528, 181, 284, 1372, 621, 1100, 943, 1101, 673, 21, 782, 1165, 675, 54, 1332, 14, 629, 1219, 1075, 765, 541, 382, 1522, 286, 390, 666, 1179, 153, 198, 519, 1527, 366, 1502, 1461, 1086, 917, 1229, 444, 1351, 248, 895, 537, 808, 1468, 513, 179, 976, 1482, 65, 950, 322, 295, 1140, 1276, 394, 997, 610, 1177, 1202, 476, 32, 631, 1182, 291, 958, 1205, 334, 457, 279, 1336, 211, 955, 1107, 1042, 829, 239, 336, 305, 608, 1418, 1067, 684, 1120, 1383, 190, 624, 815, 136, 834, 124, 1227, 792, 1412, 761, 822, 217, 396, 938, 1133, 1529, 892, 687, 627, 97, 1324, 1534, 852, 561, 162, 422, 242, 1343, 516, 412, 370, 929, 810, 1508, 1224, 847, 1049, 640, 1252, 1102, 1246, 877, 454, 143, 1390, 672, 381, 1085, 1481, 31, 1041, 814, 1528, 515, 876, 875, 1532, 550, 1429, 1272, 1490, 145, 1172, 470, 1406, 871, 75, 1533, 1264, 1150, 1271, 1416, 1076, 1002, 80, 69, 841, 401, 1185, 623, 551, 931, 1447, 1501, 207, 1019, 901, 1191, 1374, 669, 1072, 1204, 944, 1430, 415, 6, 466, 209, 501, 700, 1474, 99, 1295, 178, 907, 1115, 1273, 3, 275, 130, 429, 159, 1152, 271, 315, 664, 427, 1510, 923, 1491, 1210, 794, 707, 1129, 384, 1169, 1221, 1098, 1070, 1110, 908, 1400, 146, 616, 1319, 503, 740, 1239, 914, 1471, 1269, 1420, 1235, 1258, 203, 1173, 728, 1363, 648, 487, 945, 263, 1039, 912, 344, 1059, 1376, 903, 471, 635, 114, 459, 1315, 557, 368, 1124, 1341, 818, 570, 1355, 552, 1407, 716, 1155, 482, 799, 820, 524, 1137, 526, 869, 999, 973, 585]</value></param>
<param><key>size</key><value>1536</value></param>
</block>
<block>
<key>dab_magnitude_equalizer_vcc</key>
<param><key>id</key><value>dab_magnitude_equalizer_vcc_0</value></param>
<param><key>vlen</key><value>1536</value></param>
<param><key>num_symbols</key><value>6</value></param>
</block>
<block>
<key>dab_ofdm_coarse_frequency_correct</key>
<param><key>id</key><value>dab_ofdm_coarse_frequency_correct_0</value></param>
<param><key>cp_length</key><value>492</value></param>
<param><key>num_carriers</key><value>1536</value></param>
<param><key>fft_length</key><value>2000</value></param>
</block>
<block>
<key>dab_ofdm_ffe_all_in_one</key>
<param><key>id</key><value>dab_ofdm_ffe_all_in_one_0</value></param>
<param><key>fft_length</key><value>2000</value></param>
<param><key>num_symbols</key><value>8</value></param>
<param><key>sample_rate</key><value>2000000</value></param>
<param><key>symbol_length</key><value>2492</value></param>
<param><key>alpha</key><value>0.5</value></param>
</block>
<block>
<key>dab_ofdm_remove_first_symbol_vcc</key>
<param><key>id</key><value>dab_ofdm_remove_first_symbol_vcc_0</value></param>
<param><key>num_carriers</key><value>1536</value></param>
</block>
<block>
<key>dab_ofdm_sampler</key>
<param><key>id</key><value>dab_ofdm_sampler_0</value></param>
<param><key>cp_length</key><value>492</value></param>
<param><key>fft_length</key><value>2000</value></param>
<param><key>gap</key><value>252</value></param>
<param><key>symbols_per_frame</key><value>76</value></param>
</block>
<block>
<key>dab_repartition_vectors</key>
<param><key>id</key><value>dab_repartition_vectors_0</value></param>
<param><key>divide</key><value>864*4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen_in</key><value>3072</value></param>
<param><key>vlen_out</key><value>64</value></param>
<param><key>multiply</key><value>72</value></param>
</block>
<block>
<key>dab_select_vectors</key>
<param><key>id</key><value>dab_select_vectors_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>total_length</key><value>3072</value></param>
<param><key>num_fic_syms</key><value>3</value></param>
<param><key>num_msc_syms</key><value>72</value></param>
</block>
<block>
<key>digital_mpsk_snr_est_cc</key>
<param><key>id</key><value>digital_mpsk_snr_est_cc_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>tag_nsamples</key><value>10000</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>2000</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>400000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"going_high"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>2e6</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_slider</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_null_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>capture_tools_threshold_tag_other_stream_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>capture_tools_threshold_tag_other_stream_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>dab_ofdm_ffe_all_in_one_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>dab_ofdm_sampler_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0</source_block_id><sink_block_id>capture_tools_threshold_tag_other_stream_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>dab_ofdm_sampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>digital_mpsk_snr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>capture_tools_threshold_tag_other_stream_cc_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>capture_tools_threshold_tag_other_stream_cc_0_0</source_block_id><sink_block_id>dab_dabplus_audio_decoder_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_complex_to_interleaved_float_vcf_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_complex_to_interleaved_float_vcf_0</source_block_id><sink_block_id>capture_tools_threshold_tag_other_stream_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_complex_to_interleaved_float_vcf_0</source_block_id><sink_block_id>dab_select_vectors_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_dabplus_audio_decoder_ff_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_dabplus_audio_decoder_ff_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dab_detect_null_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_detect_null_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_detect_null_0</source_block_id><sink_block_id>dab_ofdm_ffe_all_in_one_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dab_diff_phasor_vcc_0_0</source_block_id><sink_block_id>dab_ofdm_remove_first_symbol_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_frequency_interleaver_vcc_0</source_block_id><sink_block_id>dab_complex_to_interleaved_float_vcf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_magnitude_equalizer_vcc_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_magnitude_equalizer_vcc_0</source_block_id><sink_block_id>dab_frequency_interleaver_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_magnitude_equalizer_vcc_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_magnitude_equalizer_vcc_0</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_coarse_frequency_correct_0</source_block_id><sink_block_id>dab_diff_phasor_vcc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_coarse_frequency_correct_0</source_block_id><sink_block_id>dab_ofdm_remove_first_symbol_vcc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dab_ofdm_ffe_all_in_one_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_remove_first_symbol_vcc_0</source_block_id><sink_block_id>dab_magnitude_equalizer_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_remove_first_symbol_vcc_0</source_block_id><sink_block_id>dab_magnitude_equalizer_vcc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dab_ofdm_sampler_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_sampler_0</source_block_id><sink_block_id>dab_ofdm_coarse_frequency_correct_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dab_repartition_vectors_0</source_block_id><sink_block_id>blocks_null_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_select_vectors_0</source_block_id><sink_block_id>dab_repartition_vectors_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_snr_est_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>dab_ofdm_coarse_frequency_correct_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_delay_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>dab_detect_null_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
